## src/drivers/vortex_uart/Kconfig
```kconfig
menuconfig DRIVERS_VORTEX_UART
	bool "uart_interface"
	default n
	---help---
		Enable the custom VORTEX UART Driver for logging PCU data.
```
